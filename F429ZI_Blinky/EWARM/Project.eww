<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F429ZI_Blinky.ewp</path>
  </project>
  <batchBuild />
</workspace>
